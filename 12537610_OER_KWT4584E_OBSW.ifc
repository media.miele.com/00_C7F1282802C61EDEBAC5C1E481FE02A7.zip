Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-03-18T12:14:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 18 12:14:43 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\b6bba7fa-7fcb-484c-9b34-367f6d71bf71\cfeb2c15-b0b2-440f-92a1-692cab8b26f1\ifc * Database version: 5507 * Database creation date: Mon Mar 18 12:14:42 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 18 12:14:43 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 18 12:14:43 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12537610_OER_KWT4584E_OBSW:39458451_OER_12537610_KWT4584E_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_BuildingElementProxyCommon - Reference: 39458451_OER_12537610_KWT4584E_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 39458451_OER_12537610_KWT4584E_OBSW
Material: z_Miele_Design_OBSW, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - sets with these values: 2
